include linux-hubris.inc

LICENSE = "GPL-2.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"

COMPATIBLE_MACHINE = "phyboard-mira-imx6-hubris"
