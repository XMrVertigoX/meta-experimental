inherit packagegroup

PACKAGES = "\
	packagegroup-hubris-wifi \
	"

RDEPENDS_packagegroup-hubris-wifi = "\
	linux-firmware-rtl8192cu \
	wpa-supplicant \
	"
