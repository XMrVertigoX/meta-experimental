require recipes-bsp/u-boot/u-boot-hubris.inc

SRCREV = "v${PV}"

LICENSE = "GPL-2.0"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=30503fd321432fc713238f582193b78e"
